# Keil uVision project CH555.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH555 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: VendorDefinedDev +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\ADC;.\DATAFLASH;.\GPIO;.\I2C\IICHost;.\I2C\IICSlave;.\Public;.\RGB;.\SPI;.\TIMER;.\UART;.\USB\Device
  asm include: .\Public
  group pub
    ./Public/: Debug.C
