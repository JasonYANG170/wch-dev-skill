# Keil uVision project CH559.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: USBHOST +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USB_LIB
  group Source Group 1
    ./USB/Host/: USBHOST.C
    ./USB_LIB/: CH559UFX.LIB
