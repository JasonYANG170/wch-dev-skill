# Keil uVision project LEDCTRL.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: LEDCTRL +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LEDCTRL.C
    ../../USB_LIB/: CH559UFX.LIB
