# Keil uVision project MQTT.uvproj, settings and files
target CH563 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STR912FAW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: .\MQTT;..\PUB;..\..\SRC
  asm define: STARTUP_OF_CH563
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: ..\..\SRC\CH563D64.SCF
  link misc: --entry 0x00000000
  group User
    ./: MQTT.C
  group lib
    ../PUB/: CH563NET_keil4.lib
    ../../SRC/: ISPXT56X.O
  group sys
    ../../SRC/: SYSFREQ.C STARTUP.S
  group MQTT
    ./MQTT/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
