# Keil uVision project TFTP_CLIENT.uvproj, settings and files
target CH563 (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1
  c include: ..\PUB;..\..\SRC
  asm define: STARTUP_OF_CH563
  asm include: ..\..\..\sys
  library: MicroLIB
  scatter file: ..\..\SRC\CH563D64.SCF
  group User
    ./: Main.C TFTP_CLIENT.c
  group lib
    ../../SRC/: ISPXT56X.O
    ../PUB/: CH563NET_keil4.lib
  group sys
    ../../SRC/: STARTUP.S SYSFREQ.C
