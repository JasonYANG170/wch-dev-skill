# Keil uVision project NET_CFG.uvproj, settings and files
target CH563 (ARM-ADS)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1 wLevel=1
  c include: ..\PUB;..\..\SRC
  asm define: STARTUP_OF_CH563
  library: MicroLIB
  scatter file: ..\..\SRC\CH563D64.SCF
  group user
    ./: Main.C ModuleConfig.c
  group lib
    ../PUB/: CH563NET_keil4.lib
    ../../SRC/: ISPXT56X.O
  group sys
    ../../SRC/: STARTUP.S SYSFREQ.C
