# Keil uVision project MULTICAST.uvproj, settings and files
target CH563 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\MULTICAST;..\..\SRC;..\PUB
  library: MicroLIB
  scatter file: ..\..\SRC\CH563D64.SCF
  group user
    ./: MULTICAST.C
  group lib
    ../PUB/: CH563NET_keil4.lib
  group sys
    ../../SRC/: SYSFREQ.C STARTUP.S
